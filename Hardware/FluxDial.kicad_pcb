# Repository SmallCoral/FluxDial

File README.md:

# FluxDial

基于 STM32C562CET6、50kΩ NTC 和霍尔流量传感器的圆形 LED 显示板。

固件采集温度与瞬时流量，通过 HT16K33 驱动 58mm 共阴 LED 屏，并支持温标切换、热水提示和故障显示。
J101 的 USB-C 接口仅用于 **5V 供电**，程序通过 J102 的 J-Link SWD 接口下载。

```sh
git clone https://github.com/SmallCoral/FluxDial.git
cd FluxDial
```

照片记录早期显示演示，画面数值不能用于判断传感器精度。
[更多实物照片与演示视频](Images/README.md)。

## 目录

- [项目状态](#项目状态)
- [功能与系统](#功能与系统)
- [上手](#上手)
- [仓库结构](#仓库结构)
- [文档导航](#文档导航)
- [已知问题](#已知问题)
- [文档维护](#文档维护)
- [许可证](#许可证)

## 项目状态

| 范围 | 已有证据与边界 |
| --- | --- |
| 固件 | 包含 NTC 采样、流量脉冲计时、显示及异常恢复；本次完整编译与主机测试通过 |
| 样板 | 2026-10-06 的记录确认了 NTC 读数、温标切换和板上脉冲测试；本次没有重新烧录或测量实板 |
| 实际水路 | 实际通水、流量标定和整机测量精度尚未验证 |
| 硬件检查 | 当前 KiCad 检查仍有 ERC 警告和 DRC 错误，不能据此直接宣称已通过制板检查 |

测试版本、检查结果和待确认事项集中在 [验证记录](docs/validation.md)。

## 功能与系统

- 上方显示 NTC 温度，USER 按键切换 ℃/℉。
- 下方显示瞬时流量，停流后归零。
- 支持热水提示、告警、温度探头异常及数值超限显示。
- 显示通信和 ADC 初始化失败后重试，主循环运行期间使用独立看门狗。
- 累计流量保存在 RAM，可通过调试器读取；断电后清零。

信号路径为“传感器与调理电路 → STM32 采集与换算 → HT16K33 → 圆形 LED 屏”。
完整框图及代码分层见 [系统架构](docs/architecture.md)，行为阈值见 [固件参考](docs/firmware.md)。

## 上手

1. 用 KiCad 10 打开 [Hardware/FluxDial.kicad_pro](Hardware/FluxDial.kicad_pro)。
2. 按 [硬件接口表](docs/hardware.md#接口与-mcu-引脚)核对传感器和 SWD 接线。
3. 准备 Arm GNU Toolchain、GNU Make 和 J-Link，按 [编译、烧录与首次使用](docs/getting-started.md)操作。

Linux 或具备 POSIX shell 的环境可从仓库根目录构建和运行主机测试。

```sh
make -C Firmware -j4
make -C Firmware test
```

Windows PowerShell 的对应入口如下。

```powershell
./Firmware/tools/build.ps1
./Firmware/tools/test.ps1
```

生成文件为 `Firmware/build/FluxDial.elf`、`FluxDial.hex` 和 `FluxDial.bin`。
工具安装位置、脚本参数和烧录步骤以 [上手文档](docs/getting-started.md)为准。

## 仓库结构

```text
FluxDial/
├── docs/                  # 当前维护的设计、操作、固件和验证文档
├── Documentation/         # 器件资料、历史报告和旧文档入口
│   ├── Datasheets/        # 芯片、探头、流量传感器和显示屏资料
│   ├── Reports/           # 既有实测记录、历史导出和交互式 BOM
│   └── BOM.csv            # 既有器件清单，已知与当前工程存在差异
├── Firmware/              # 应用、BSP、启动代码、官方驱动和工具
├── Hardware/              # KiCad 工程、四张功能页、本地库和检查脚本
└── Images/                # 样板照片、视频及规格书预览
```

器件资料和工程文件保持原有目录，项目库通过相对路径引用。

## 文档导航

| 目标 | 入口 |
| --- | --- |
| 接线、编译、烧录和观察显示 | [上手](docs/getting-started.md) |
| 理解数据流与代码职责 | [系统架构](docs/architecture.md) |
| 查电源、器件、接口、引脚和显示矩阵 | [硬件参考](docs/hardware.md) |
| 查采样周期、换算、状态码与诊断变量 | [固件参考](docs/firmware.md) |
| 区分历史实测、本次检查和待验证项 | [验证记录](docs/validation.md) |
| 查原厂资料、历史 BOM 和封装图 | [资料索引](Documentation/README.md) |
| 查本轮文档修改及复审结果 | [文档审查记录](docs/documentation-audit-2026-10-29.md) |

## 已知问题

- 归档 BOM 与当前工程存在器件值差异，见 [晶振电容核对说明](docs/hardware.md#mcu-电源与时钟)。
- 当前 PCB 仍有装配间距、悬空走线端点和丝印相关检查项，见 [检查结果](docs/validation.md#本次检查)。
- 流量采用厂商标称系数，尚无实测精度数据；静止水流和未接流量传感器都会显示零。
- 温标选择和累计流量不写入 Flash，产品固件也不包含 USB 数据通信或 USB 下载功能。

## 文档维护

详细参数分别由硬件参考和固件参考维护，其他页面通过链接引用。
更新记录时注明所用提交、工具和验证范围，并保留旧记录的日期与边界。
[文档目录](docs/README.md)列出了各页职责。

## 许可证

仓库目前没有覆盖 FluxDial 自有代码、硬件设计和文档的项目级许可证。
CMSIS 与 ST 驱动保留各自的许可证，不能用这些许可证推定整个项目的授权范围。
具体文件和待确认事项见 [许可证与第三方资料](docs/licenses.md)。

## KiCad design Hardware/FluxDial.kicad_pcb

File Hardware/README.md:

# FluxDial 硬件工程

用 KiCad 10 打开 [FluxDial.kicad_pro](FluxDial.kicad_pro)。
工程包含 [原理图主页](FluxDial.kicad_sch)、四张功能页和 [PCB](FluxDial.kicad_pcb)。

| 目标 | 入口 |
| --- | --- |
| 查看电源、关键器件、接口与引脚 | [硬件参考](../docs/hardware.md) |
| 理解原理图分工与信号路径 | [系统架构](../docs/architecture.md) |
| 接线、编译和烧录 | [上手](../docs/getting-started.md) |
| 查看当前 ERC/DRC 与已知问题 | [验证记录](../docs/validation.md) |
| 查符号、封装与 3D 模型 | [libraries](libraries/) |
| 查原厂手册、历史 BOM 和检查导出 | [资料索引](../Documentation/README.md) |
| 查看样板照片与视频 | [Images](../Images/README.md) |

本地库名为 `FluxDial`，由 [sym-lib-table](sym-lib-table)与 [fp-lib-table](fp-lib-table)加载。
`tools/` 中的旧检查脚本依赖历史设计清单，使用边界见 [报告说明](../Documentation/Reports/README.md)。
本轮文档工作没有修改工程文件或重新生成交互式 BOM。

Notes on the sheet:
3.3V 供电、USB 烧录
SWD 调试、启动与复位
NTC 温度、霍尔流量 用户按键与信号调理
I²C 显示控制 PB6：时钟 PB7：数据
主控：STM32C562CET6，LQFP48，512KB 闪存 / 128KB 运行内存。 J101/C668623 仅允许 5V 供电；下载与调试使用 J102 / J-Link SWD。
温度采样：PA0 流量脉冲：PA1 用户按键：PC13
温度与流量显示系统 · 模块关系导航
5V 显示供电
5V / 3.3V 传感器供电
STM32C562CET6 最小系统与供电去耦
Type-C 6P 仅供电接口 J101 5V 输入、5V / 3.3V DCDC
HT16K33 显示驱动 58mm 共阴 LED 屏

Parts:
C401, C402, C403, C406: 100n; Capacitor_SMD__C_0603_1608Metric
C404: 4.7u / 10V; Capacitor_SMD__C_0603_1608Metric
C405: 2.2u / 10V; Capacitor_SMD__C_0603_1608Metric
C407, C408: 6.8p / C0G; Capacitor_SMD__C_0603_1608Metric
U401: STM32C562CET6; STM32C562CET6_LQFP48_ST
Y401: 24MHz / CL=10pF; Abracon_ABM8_3.2x2.5mm

Connections:
+3V3: C401.1, C402.1, C403.1, C404.1, C406.1, U401.9 (VREF+), U401.24 (VDD), U401.36 (VDD), U401.48 (VDD); also elsewhere on the board
/STM32C562 最小系统/MCU_VCAP: C405.1, U401.22 (VCAP)
FLOW_PULSE: U401.11 (PA1); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, U401.8 (VREF-), U401.23 (VSS), U401.35 (VSS), U401.47 (VSS), Y401.2 (G), Y401.4 (G); also elsewhere on the board
I2C_SCL: U401.42 (PB6); also elsewhere on the board
I2C_SDA: U401.43 (PB7); also elsewhere on the board
MCU_BOOT0: U401.44 (PH2-BOOT0); also elsewhere on the board
MCU_NRST: U401.7 (NRST); also elsewhere on the board
NTC_ADC: U401.10 (PA0); also elsewhere on the board
unnamed: C407.1, U401.5 (PH0-OSC_IN), Y401.1
unnamed: C408.1, U401.6 (PH1-OSC_OUT), Y401.3
SWCLK: U401.37 (PA14); also elsewhere on the board
SWDIO: U401.34 (PA13); also elsewhere on the board
USER_KEY: U401.2 (PC13); also elsewhere on the board

Notes on the sheet:
STM32C562CET6 最小系统：供电、参考与外围接口
外围接口引脚： PA0：温度 ADC；PA1：流量计数； PA11 / PA12：空接；PB6 / PB7：I²C； PA13 / PA14：SWD；PC13：用户按键。
启动与复位按键、上下拉和 J102 SWD 接口已在电源页绘制。 下载与在线调试统一使用 J-Link；J101 不含 USB 数据。 未用 GPIO 在固件中配置为确定电平；保留 SWD 调试。 本页电阻、电容为 0603；未使用引脚标记为空接。
24MHz 外部晶振；负载电容初值 12pF 应用程序启用 HSE；PA11/PA12 当前空接，下载调试使用 J-Link SWD
勘误提示：若以后增加 LSE 晶振， 须避开 PC13 跳变对 LSE 的影响。 参见 ES0661 第 2.2.2 节。
电源去耦：分别靠近 VDD 24、36、48 脚；另加总去耦
VCAP 电容：2.2µF、额定电压至少 10V； 3MHz 时 ESR＜20mΩ。紧靠 U401 的 22 脚。 仅接专用电容到地，不能连接 3.3V。

Parts:
C101: 100n / 25V; Capacitor_SMD__C_0603_1608Metric
C102, C110: 10u / 35V; Capacitor_SMD__C_1206_3216Metric
C103, C105, C107, C108: 22u / 10V; Capacitor_SMD__C_1206_3216Metric
C104, C106, C109: 100n; Capacitor_SMD__C_0603_1608Metric
F101: 0.5A / 24V; Fuse__Fuse_1206_3216Metric
J101: SHOU HAN TYPE-C 6P(073); Connector_USB__SHOU_HAN_TYPE-C-6P-073_C668623
J102: SWD / XH 2.50mm; Connector_JST__JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
L101: 3.9u / 3A; Inductor_Sunlord_SWPA4030S
L102: 4.7u / 2.9A; Inductor_Sunlord_SWPA4030S
R101, R102: 5.1k 1%; Resistor_SMD__R_0603_1608Metric
R103, R104: 10k; Resistor_SMD__R_0603_1608Metric
SW101: 启动（BOOT）; Button_Switch_SMD__SW_SPST_B3U-1000P
SW102: 复位（RESET）; Button_Switch_SMD__SW_SPST_B3U-1000P
U101: AP63203WU-7; Package_TO_SOT_SMD__SOT-23-6
U102: AP63205WU-7; Package_TO_SOT_SMD__SOT-23-6

Connections:
+3V3: C103.1, C105.1, J102.1 (VREF_/_+3V3), L101.2, R104.1, SW101.1, U101.1 (FB); also elsewhere on the board
+5V: C107.1, C108.1, L102.2, U102.1 (FB); also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C107.2, C108.2, C110.2, J101.A12 (GND), J101.B12 (GND), J101.SH (SHIELD), J102.4 (GND), R101.2, R102.2, R103.2, SW102.2, U101.4 (GND), U102.4 (GND); also elsewhere on the board
MCU_BOOT0: R103.1, SW101.2; also elsewhere on the board
MCU_NRST: C104.1, R104.2, SW102.1; also elsewhere on the board
unnamed: F101.1, J101.A9 (VBUS), J101.B9 (VBUS)
unnamed: J101.A5 (CC1), R101.1
unnamed: J101.B5 (CC2), R102.1
unnamed: C106.1, U101.6 (BST)
unnamed: C106.2, L101.1, U101.5 (SW)
unnamed: C109.1, U102.6 (BST)
unnamed: C109.2, L102.1, U102.5 (SW)
SWCLK: J102.3 (SWCLK); also elsewhere on the board
SWDIO: J102.2 (SWDIO); also elsewhere on the board
VIN_SYS: C101.1, C102.1, C110.1, F101.2, U101.2 (EN), U101.3 (VIN), U102.2 (EN), U102.3 (VIN)

Notes on the sheet:
程序下载与在线调试统一使用 J102 / J-Link SWD；J101 仅供电，不支持 USB 数据。
启动与复位按键
J101/C668623 为仅供电 6P Type-C，器件资料额定 5V/3A。 禁止从 J101 输入 12V。 后级 VIN_SYS 与两路 DCDC 仍按 5～12V 设计； 若需 12V 输入，必须更换额定电压≥12V 的连接器。 U102/AP63205 生成 +5V，U101/AP63203 独立生成 +3V3。 DCDC 输入回路与 SW 铜皮须紧凑布局，远离 Type-C 和 ADC。
Type-C 6P 供电与 J-Link SWD 调试
1=VREF（板上 3.3V） 2=SWDIO 3=SWCLK 4=GND VREF 仅供 J-Link 检测目标电平；4 芯接口不含 NRST

Parts:
C301, C303, C304, C305: 100n; Capacitor_SMD__C_0603_1608Metric
C302: 1n; Capacitor_SMD__C_0603_1608Metric
D301: BAV199; Package_TO_SOT_SMD__SOT-23
J301: NTC 接口 / XH 2.50mm; Connector_JST__JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J302: BTL-004A / XH 2.50mm; Connector_JST__JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R301: 49.9k 0.1%; Resistor_SMD__R_0603_1608Metric
R302: 1k; Resistor_SMD__R_0603_1608Metric
R303, R305: 10k; Resistor_SMD__R_0603_1608Metric
R304: 4.7k; Resistor_SMD__R_0603_1608Metric
SW301: 单位切换; Button_Switch_SMD__SW_SPST_B3U-1000P
U301: SN74LVC1G17DCKR; Package_TO_SOT_SMD__SOT-353_SC-70-5

Connections:
+3V3: C303.1, D301.2 (K2), J301.1 (+3V3), R305.1, U301.5 (VCC); also elsewhere on the board
+5V: C304.1, J302.1 (红线+5V), R303.1; also elsewhere on the board
FLOW_PULSE: U301.4; also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, C305.2, D301.1 (A1), J302.3 (白线GND), R301.2, SW301.1, U301.3 (GND); also elsewhere on the board
NTC_ADC: C301.1, D301.3 (K1/A2), R302.2; also elsewhere on the board
unnamed: C302.1, R304.2, U301.2
unnamed: J301.2 (信号), R301.1, R302.1
unnamed: J302.2 (黄线), R303.2, R304.1
USER_KEY: C305.1, R305.2, SW301.2; also elsewhere on the board

Notes on the sheet:
NTC 温度输入：25℃ 时为 50kΩ，B25/50=3950K
每升 660 个脉冲，白线为地。 厂商量程描述不一致，标定时确认。
霍尔流量输入：F[Hz] = 11 × Q[L/min]
R_NTC = 49.9k × (Vref/Vadc − 1)，按厂商阻温表换算温度。 开路趋近 0V，短路趋近 Vref；ADC 使用较长采样时间。

Parts:
C201: 100n; Capacitor_SMD__C_0603_1608Metric
C202: 2.2u / 10V; Capacitor_SMD__C_0603_1608Metric
DS201: 5858-1DRWB-10; ALS5858_1DRWB_10
Q201, Q202: BSS138; Package_TO_SOT_SMD__SOT-23
R201, R202, R203, R204, R205, R206, R207, R208, R209, R210: 330R; Resistor_SMD__R_0603_1608Metric
R211, R212, R213, R214: 4.7k; Resistor_SMD__R_0603_1608Metric
U201: HT16K33 / SOP28; Package_SO__SOIC-28W_7.5x17.9mm_P1.27mm

Connections:
+3V3: Q201.1 (G), Q202.1 (G), R211.1, R213.1; also elsewhere on the board
+5V: C201.1, C202.1, R212.1, R214.1, U201.28 (VDD); also elsewhere on the board
GND: C201.2, C202.2, U201.1 (VSS); also elsewhere on the board
I2C_SCL: Q201.2 (S), R211.2; also elsewhere on the board
I2C_SDA: Q202.2 (S), R213.2; also elsewhere on the board
unnamed: DS201.15 (A), R201.2
unnamed: DS201.14 (B), R202.2
unnamed: DS201.13 (C), R203.2
unnamed: DS201.1 (COM1), U201.2 (COM0)
unnamed: DS201.2 (COM2), U201.3 (COM1)
unnamed: DS201.3 (COM3), U201.4 (COM2)
unnamed: DS201.4 (COM4), U201.5 (COM3)
unnamed: DS201.5 (COM5), U201.6 (COM4)
unnamed: DS201.6 (COM6), U201.7 (COM5)
unnamed: DS201.12 (D), R204.2
unnamed: DS201.11 (E), R205.2
unnamed: DS201.10 (F), R206.2
unnamed: DS201.9 (G), R207.2
unnamed: DS201.8 (H), R208.2
unnamed: DS201.7 (I), R209.2
unnamed: DS201.16 (J), R210.2
unnamed: Q201.3 (D), R212.2, U201.26 (SCL)
unnamed: Q202.3 (D), R214.2, U201.27 (SDA)
unnamed: R201.1, U201.25 (ROW0)
unnamed: R202.1, U201.24 (ROW1)
unnamed: R203.1, U201.23 (ROW2)
unnamed: R204.1, U201.22 (ROW3)
unnamed: R205.1, U201.21 (ROW4)
unnamed: R206.1, U201.20 (ROW5)
unnamed: R207.1, U201.19 (ROW6)
unnamed: R208.1, U201.18 (ROW7)
unnamed: R209.1, U201.17 (ROW8)
unnamed: R210.1, U201.16 (ROW9)

Notes on the sheet:
I²C 地址为 0x70，初次使用 100kHz；BSS138 转换 3.3V / 5V 电平。 未使用的输出悬空，不加地址选择二极管；初次点屏使用低亮度。 R201～R210 限制 LED 峰值电流，需用样屏确认亮度。
LED 显示：6 个公共阴极 × 10 条阳极段线
屏幕直径 58mm，双排间距 35.08mm，同排针距 2.54mm。 暂定钻孔 1.0mm；孔径与正面安装方向须用实物核对。
